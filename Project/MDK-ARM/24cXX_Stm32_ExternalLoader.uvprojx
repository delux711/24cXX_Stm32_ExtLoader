# Keil uVision project 24cXX_Stm32_ExternalLoader.uvprojx, settings and files
target 24C16_Stm32F103_ExternalLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 24c16_Stm32F103_ExternalLoader
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  AfterMake: cmd.exe /C copy "!L" "l:\Install\STMicroelectronics\STM32 ST-LINK Utility\ST-LINK Utility\ExternalLoader\@L.stldr"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, I2C_24C16
  c include: ..\..\Includes\Library_Files;..\..\Includes\Loader_Files;..\..\Includes\CMSIS_Files;..\..\Includes\HI2C
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: Target.lin
  link misc: --diag_suppress L6305
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c stm32_i2c_24cXX.c
    ../../Sources/Library_Files/: hi2c0.c system_stm32f10x.c system_stm32l4xx.c
target 24C512_Stm32F103_ExternalLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: 24c512_Stm32F103_ExternalLoader
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  AfterMake: as above
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, I2C_24C512
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: Target.lin
  link misc: --diag_suppress L6305
target 24C16_St,32L476_ExternalLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 24c16_Stm32L4_ExternalLoader
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  AfterMake: as above
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L476xx, I2C_24C16
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Target.lin
  link misc: --diag_suppress L6305
target 24C512_St,32L476_ExternalLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: 24c512_Stm32L4_ExternalLoader
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  AfterMake: as above
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L476xx, I2C_24C512
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Target.lin
  link misc: --diag_suppress L6305
