# Keil uVision project 24c02_Stm32F103_ExternalLoader.uvprojx, settings and files
target 24C02_Stm32F103_ExternalLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 24c02_Stm32F103_ExternalLoader
  AfterMake: cmd.exe /C copy "!L" "..\..\@L.stldr"
  AfterMake: cmd.exe /C copy "!L" "l:\Install\STMicroelectronics\STM32 ST-LINK Utility\ST-LINK Utility\ExternalLoader\24c02.stldr"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, I2C_24C02
  c include: ..\..\Includes\Library_Files;..\..\Includes\Loader_Files;..\..\Includes\CMSIS_Files;..\..\Includes\HI2C
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: Target.lin
  link misc: --diag_suppress L6305
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c stm32_i2c_24c02.c
    ../../Sources/Library_Files/: system_stm32f10x.c hi2c0.c
